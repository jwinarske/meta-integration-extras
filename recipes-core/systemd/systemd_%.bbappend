
PACKAGECONFIG:remove = "networkd resolved"
